# Repository KarlZeilhofer/EtherDue-EMVC-PA-Monitor-2

## KiCad design EtherDue.kicad_pcb

Parts:
C101, C102, C103, C104, C105, C106, C107: 1nF/X7R; C_0603
C1503, C1703: 100n/X7R; C_0603
D101, D102, D103: BAT54S; sot23
JP101, JP102: JUMPER3; Pin_Header_Straight_1x03
P101: CONN_02X04; vasch_strip_4x2
P102, P103: MSTBV3
P104: MSTBV6
Q101, Q102: IPB020NE7N3G; d2-pak
R101, R102: Shunt; WSL4026
R103: 1k; R_0603
R104, R105: 4k7; R_0603
U101: AD7415; SOT23-5
U1701: MCP6H04; SOIC-14_3.9x8.7mm_Pitch1.27mm

Connections:
/Analog I/O/+3V3: C101.1, C104.1, C106.1, C1503.1, D102.3 (cathode), D103.3 (cathode), R104.1, R105.1, U101.1 (AS), U101.3 (VDD); also elsewhere on the board
/Fuse-Reset B/Reset\: JP101.2; also elsewhere on the board
/eFuse 1 (10A)/+Shunt: R101.SA; also elsewhere on the board
/eFuse 1 (10A)/-Shunt: R101.SB; also elsewhere on the board
/eFuse 1 (10A)/Gate: Q101.G; also elsewhere on the board
/eFuse 1 (10A)/LED_K: P101.4; also elsewhere on the board
/eFuse 1 (10A)/Source: P102.3, Q101.S; also elsewhere on the board
/eFuse 2 (10A)/+Shunt: R102.SA; also elsewhere on the board
/eFuse 2 (10A)/-Shunt: R102.SB; also elsewhere on the board
/eFuse 2 (10A)/Gate: Q102.G; also elsewhere on the board
/eFuse 2 (10A)/LED_K: P101.6; also elsewhere on the board
/eFuse 2 (10A)/Reset\: JP101.1, P101.5; also elsewhere on the board
/eFuse 2 (10A)/Source: P103.3, Q102.S; also elsewhere on the board
/eFuse 3 (60A)/+Shunt: P104.5; also elsewhere on the board
/eFuse 3 (60A)/-Shunt: P104.4; also elsewhere on the board
/eFuse 3 (60A)/Comp+: JP102.2; also elsewhere on the board
/eFuse 3 (60A)/Gate: P104.1; also elsewhere on the board
/eFuse 3 (60A)/ISense: JP102.1; also elsewhere on the board
/eFuse 3 (60A)/LED_K: P101.8; also elsewhere on the board
/eFuse 3 (60A)/Reset\: JP101.3, P101.7; also elsewhere on the board
/eFuse 3 (60A)/Source: P104.2; also elsewhere on the board
AD0: C104.2, C105.1, D102.2 (AK); also elsewhere on the board
AD1: C106.2, C107.1, D103.2 (AK); also elsewhere on the board
unnamed: C102.2, C103.1, D101.2 (AK), JP102.3, R103.1
unnamed: P102.1, R101.A
unnamed: P103.1, R102.A
unnamed: P104.6, R103.2
unnamed: Q101.D, R101.B
unnamed: Q102.D, R102.B
unnamed: U1701.13 (-), U1701.14
PIN25: R104.2, U101.5 (SDA); also elsewhere on the board
PIN26: R105.2, U101.4 (SCL); also elsewhere on the board

Notes on the sheet:
Labelling scheme: Use Global labels for simple 1:1 I/O pin<->MCU connectors, hierarchical labels for all other inter-sheet connections.
Existing EtherDue Schematic
Outputs: 0.4...2.2V
resetB
Board Temperature Sensor
Notes for the PA-Monitor: If not otherwise stated all resistors and capacitors are in an SMD-0603 package. All vias for decoupling capacitors have a drill diameter of 0.6mm or greater.
Notes on the 1nF-1nF-BAT54 network of all ADC inputs. The high-side C and the dual-diode should be placed near the connector of the signal. The low-side C should be placed near the ADC input pin.
Shunt
LEM
Select Signal Source for eFuse 3
Select eFuse resetted by Fuse-Reset B
eFuse 2
eFuse 3
Changed from I2C_1 to I2C_0-3

Parts:
C201, C202, C205: 22pF; SM0402
C203, C204: 22pF_NM; SM0402
C206, C207, C208: 100nF; SM0402
C209: 10nF; C0402
C210: 10uF; SM0603_Capa
D201, D202, D204: YELLOW; LED-0603
D203: GREEN; LED-0603
IC201: ATSAM3X8E; TQFP144
L201: MH2029-300Y; MH2029
R201: 6k8 1%; SM0402_r
R202, R203: 39R 1%; SM0402_r
R204: 100K; SM0402_r
R205, R207: 1K5; SM0402_r
R206: 1K; RES_CAY16
R208: 10K; SMD-0402_r
R209: 33R; R_0402
SJ201, SJ203: OPEN; SJ_OPEN
SJ202: CLOSED; SJ_SHORTED
SW201: ERASE; TACTILE_SWITCH_SMD_2PIN_TINY
SW202: RESET; TACTILE_SWITCH_SMD_2PIN_TINY
U202: FDN340P; SOT23_MOSFET
U203: LMV358IPWR; TSSOP8
X201: TXC 7A 12MHz 18pF; TXC_7A
X202: ABS07L 32.768kHz; ABS07L

Connections:
+3.3V: C208.1, C209.1, C210.1, IC201.11 (VDDIO), IC201.52 (VDDBU), IC201.57 (VDDIN), IC201.62 (VDDIO), IC201.105 (VDDIO), IC201.125 (VDDIO), R204.1, R205.1, R206.3 (7), R206.5 (7), R206.7, R207.1, R208.1, SJ202.1, SW201.2, U202.S; also elsewhere on the board
+5V: U203.8 (V+); also elsewhere on the board
/Connectors//MASTER-RESET: C208.2, C209.2, IC201.47 (NRSTB), SW202.1; also elsewhere on the board
/Connectors/D+: IC201.37 (DHSDP), R203.1; also elsewhere on the board
/Connectors/D-: IC201.38 (DHSDM), R202.1; also elsewhere on the board
/Connectors/RX: IC201.27 (PA8); also elsewhere on the board
/Connectors/TX: IC201.2 (PA9); also elsewhere on the board
/Connectors/UOTGID: IC201.129 (PB11); also elsewhere on the board
/Connectors/XUSB: IC201.39 (VBUS); also elsewhere on the board
/MCU//ERASE_CMD: R208.2, U202.G; also elsewhere on the board
/MCU/ERASE: IC201.130 (PC0), SW201.1, U202.D
/MCU/LED_ON: R206.1 (7), U203.1, U203.2 (-)
/MCU/RXL: D202.K, IC201.103 (PC30)
/MCU/TXL: D201.K, IC201.107 (PA21)
/MCU/UOTGVBOF: IC201.128 (PB10); also elsewhere on the board
/MCU/VDDANA: IC201.73 (VDDANA); also elsewhere on the board
/MCU/VDDOUT: IC201.10 (VDDCORE), IC201.45 (VDDCORE), IC201.56 (VDDOUT), IC201.61 (VDDCORE), IC201.104 (VDDCORE), IC201.124 (VDDCORE); also elsewhere on the board
/MCU/VDDOUTMI: IC201.41 (VDDUTMI); also elsewhere on the board
/MCU/VDDPLL: IC201.34 (VDDPLL); also elsewhere on the board
AD0: IC201.78 (PA16); also elsewhere on the board
AD1: IC201.79 (PA24); also elsewhere on the board
AD2: IC201.80 (PA23); also elsewhere on the board
AD3: IC201.81 (PA22); also elsewhere on the board
AD4: IC201.82 (PA6); also elsewhere on the board
AD5: IC201.83 (PA4); also elsewhere on the board
AD6: IC201.84 (PA3); also elsewhere on the board
AD7: IC201.85 (PA2); also elsewhere on the board
AD8: IC201.88 (PB17); also elsewhere on the board
AD9: IC201.89 (PB18); also elsewhere on the board
AD10: IC201.90 (PB19); also elsewhere on the board
AD11/TXD3: IC201.91 (PB20); also elsewhere on the board
AD14/RXD3: IC201.92 (PB21); also elsewhere on the board
AREF: SJ203.1; also elsewhere on the board
CANRX0: IC201.24 (PA1); also elsewhere on the board
CANTX0: IC201.23 (PA0); also elsewhere on the board
CANTX1/IO: IC201.140 (PB14); also elsewhere on the board
DAC0/CANRX1: IC201.76 (PB15); also elsewhere on the board
DAC1: IC201.77 (PB16); also elsewhere on the board
EEXTINT: IC201.25 (PA5)
EMDC: IC201.123 (PB8)
EMDIO: IC201.127 (PB9)
ERXD0: IC201.120 (PB5)
ERXD1: IC201.121 (PB6)
ERX_DV: IC201.119 (PB4)
ERX_ER: IC201.122 (PB7)
ETXD0: IC201.115 (PB2)
ETX_CLK: IC201.113 (PB0)
ETX_EN: IC201.114 (PB1)
EXTD1: IC201.118 (PB3)
JTAG_TCK: IC201.28 (PB28); also elsewhere on the board
JTAG_TDI: IC201.29 (PB29); also elsewhere on the board
JTAG_TDO: IC201.30 (PB30); also elsewhere on the board
JTAG_TMS: IC201.31 (PB31); also elsewhere on the board
MISO: IC201.108 (PA25); also elsewhere on the board
MOSI: IC201.109 (PA26); also elsewhere on the board
unnamed: C201.2, R209.2, X201.1
unnamed: C202.2, IC201.36 (XIN), X201.2
unnamed: C203.2, IC201.49 (XOUT32), X202.1
unnamed: C204.2, IC201.48 (XIN32), X202.2
unnamed: C205.1, IC201.40 (VBG), R201.1
unnamed: C206.1, L201.1, SJ202.2, SJ203.2
unnamed: C207.1, IC201.75 (ADVREF), L201.2
unnamed: D201.A, R206.8
unnamed: D202.A, R206.6 (8)
unnamed: D203.A, R206.4 (8)
unnamed: D204.A, R206.2 (8)
unnamed: IC201.35 (XOUT), R209.1
unnamed: IC201.42 (DFSDP), R203.2
unnamed: IC201.43 (DFSDM), R202.2
unnamed: IC201.51 (TST), SJ201.2
unnamed: IC201.53 (FWUP), R204.2
PIN22: IC201.1 (PB26); also elsewhere on the board
PIN23: IC201.7 (PA14); also elsewhere on the board
PIN24: IC201.8 (PA15); also elsewhere on the board
PIN25: IC201.13 (PD0); also elsewhere on the board
PIN26: IC201.14 (PD1); also elsewhere on the board
PIN27: IC201.15 (PD2); also elsewhere on the board
PIN28: IC201.16 (PD3); also elsewhere on the board
PIN29: IC201.19 (PD6); also elsewhere on the board
PIN30: IC201.22 (PD9); also elsewhere on the board
PIN31: IC201.26 (PA7); also elsewhere on the board
PIN32: IC201.32 (PD10); also elsewhere on the board
PIN33: IC201.55 (PC1); also elsewhere on the board
PIN34: IC201.59 (PC2); also elsewhere on the board
PIN35: IC201.60 (PC3); also elsewhere on the board
PIN36: IC201.116 (PC4); also elsewhere on the board
PIN37: IC201.63 (PC5); also elsewhere on the board
PIN38: IC201.64 (PC6); also elsewhere on the board
PIN39: IC201.65 (PC7); also elsewhere on the board
PIN40: IC201.66 (PC8); also elsewhere on the board
PIN41: IC201.67 (PC9); also elsewhere on the board
PIN42: IC201.71 (PA19); also elsewhere on the board
PIN43: IC201.72 (PA20); also elsewhere on the board
PIN44: IC201.101 (PC19); also elsewhere on the board
PIN45: IC201.100 (PC18); also elsewhere on the board
PIN46: IC201.99 (PC17); also elsewhere on the board
PIN47: IC201.98 (PC16); also elsewhere on the board
PIN48: IC201.97 (PC15); also elsewhere on the board
PIN49: IC201.96 (PC14); also elsewhere on the board
PIN50: IC201.95 (PC13); also elsewhere on the board
PIN51: IC201.94 (PC12); also elsewhere on the board
PWM2: IC201.144 (PB25); also elsewhere on the board
PWM3: IC201.139 (PC28); also elsewhere on the board
PWM5: IC201.136 (PC25); also elsewhere on the board
PWM6: IC201.135 (PC24); also elsewhere on the board
PWM7: IC201.134 (PC23); also elsewhere on the board
PWM8: IC201.133 (PC22); also elsewhere on the board
PWM9: IC201.132 (PC21); also elsewhere on the board
PWM11: IC201.20 (PD7); also elsewhere on the board
PWM12: IC201.21 (PD8); also elsewhere on the board
PWM13: IC201.68 (PB27), U203.3 (+); also elsewhere on the board
RXD0: IC201.18 (PD5); also elsewhere on the board
RXD1: IC201.5 (PA12); also elsewhere on the board
RXD2: IC201.3 (PA10); also elsewhere on the board
SCK: IC201.110 (PA27); also elsewhere on the board
SCL0-3: IC201.87 (PB13), R207.2; also elsewhere on the board
SCL1: IC201.70 (PA18); also elsewhere on the board
SDA0-3: IC201.86 (PB12), R205.2; also elsewhere on the board
SDA1: IC201.9 (PA17); also elsewhere on the board
SS0/PWM10: IC201.102 (PC29), IC201.111 (PA28); also elsewhere on the board
SS1/PWM4: IC201.112 (PA29), IC201.137 (PC26); also elsewhere on the board
SS3: IC201.142 (PB23)
TXD0: IC201.17 (PD4); also elsewhere on the board
TXD1: IC201.6 (PA13); also elsewhere on the board
TXD2: IC201.4 (PA11); also elsewhere on the board

Notes on the sheet:
i2c 3.3v pullups
Ethernet (not used)
JTAG
See separate sheet "Power" for details of MCU power decoupling
Reset
LEDs
AREF
(SD)
(ETH)
internal pullup

Parts:
C301, C302: 100nF; SM0402
C303, C304: 22pF; SM0402
C305: 1uF; SM0402
D301: CD1206-S; 1206_DIODE
D302, D303: YELLOW; LED-0603
F301: 500mA PTC 1812; SM1812
IC301: ATMEGA16U2; QFN32
ICSP301: M02X03; Pin_Header_Straight_2x03
P301: USB_5PIN_SHELL; USB-MICRO_TH_4PEGS
R301, R302: 22R; SM0402_r
R303, R310: 10K; SM0402_r
R304: 1K5; SM0402_r
R305: 2K7; SM0402_r
R306, R307, R308, R309: 1K; SM0402_r
X301: TXC 7A 16MHz 18pF; TXC_7A
Z301, Z302: PGB1010603; 0603

Connections:
+5V: C302.1, D301.K, IC301.4 (VCC), IC301.32 (AVCC), ICSP301.2, R303.1, R308.2, R309.2; also elsewhere on the board
/Connectors//MASTER-RESET: R306.2; also elsewhere on the board
/Connectors/RX: R304.2, R305.1; also elsewhere on the board
/Connectors/TX: IC301.8 ((RXD1/AIN1/INT2)PD2); also elsewhere on the board
/Connectors/USBVCC: R307.2; also elsewhere on the board
/MCU//ERASE_CMD: IC301.23 ((OC1A/PCINT8)PC6); also elsewhere on the board
/Mega16U2/16U2_TX: IC301.9 ((TXD1/INT3)PD3), R304.1
/Mega16U2/MISO: IC301.17 ((PDO/MISO/PCINT3)PB3), ICSP301.1
/Mega16U2/MOSI: IC301.16 ((PDI/MOSI/PCINT2)PB2), ICSP301.4
/Mega16U2/RD+: IC301.29 (D+), R302.2
/Mega16U2/RD+_CONN: P301.3 (D+), R302.1, Z302.2
/Mega16U2/RD-: IC301.30 (D-), R301.2
/Mega16U2/RD-_CONN: P301.2 (D-), R301.1, Z301.2
/Mega16U2/RESET: D301.A, IC301.24 (nRESET(PC1/DW)), ICSP301.5, R303.2
/Mega16U2/RESET_CMD: IC301.22 ((INT4/ICP1/CLK0)PC7), R306.1
/Mega16U2/RXL: D303.K, IC301.10 ((INT5/AIN3)PD4)
/Mega16U2/SCK: IC301.15 ((SCLK/PCINT1)PB1), ICSP301.3
/Mega16U2/TXL: D302.K, IC301.11 ((XCK/AIN4/PCINT12)PD5)
/Mega16U2/USB Boot Enable: IC301.13 ((CTS/HWB/AIN6/TO/INT7)PD7), R310.1
/Mega16U2/USBVCCU2: C301.1, F301.2, IC301.31 (UVCC); also elsewhere on the board
/Mega16U2/USBVCCU2_CONN: F301.1, P301.1 (VCC)
/Mega16U2/XTAL1: C304.2, IC301.1 (XTAL1), X301.1
/Mega16U2/XTAL2: C303.2, IC301.2 (XTAL2(PC0)), X301.2
unnamed: C305.1, IC301.27 (UCAP)
unnamed: D302.A, R308.1
unnamed: D303.A, R309.1
unnamed: IC301.26 ((PCINT10)PC4), R307.1

Notes on the sheet:
ATMEGA16U2 is running at 5V

Parts:
C401: 10nF; SM0402
C402, C403: 10uF; SM0603_Capa
C404, C405, C406, C407: 22pF; C0402
DEBUG401: M04; Pin_Header_Straight_1x04
F401: 500mA PTC 1812; SM1812
JP401: JTAG; 2X5_127MMPITCH
P401: USB_5PIN_SHELL; USB-MICRO_TH_4PEGS
R401: 100K; RES_CAY16
R403: 10K; SM0402_r
SHIELD401: ARDUINO_DUE_SHIELD
SJ401: CLOSED; SJ_SHORTED
VR401, VR402, VR403: PGB1010603; 0603

Connections:
+3.3V: JP401.1, R401.2 (8), R401.4 (8), R401.6 (8), R401.8, SHIELD401.3V3, SHIELD401.IO_R (IOREF); also elsewhere on the board
+5V: SHIELD401.5V, SHIELD401.5V_4, SHIELD401.5V_5, SHIELD401.SP2 (Vcc); also elsewhere on the board
/Connectors//MASTER-RESET: DEBUG401.4, SHIELD401.RST, SHIELD401.SP5 (Reset), SJ401.2; also elsewhere on the board
/Connectors/D+: P401.3 (D+), VR402.1; also elsewhere on the board
/Connectors/D-: P401.2 (D-), VR401.1; also elsewhere on the board
/Connectors/RX: SHIELD401.0 (RX0); also elsewhere on the board
/Connectors/TX: SHIELD401.1 (TX0); also elsewhere on the board
/Connectors/UOTGID: P401.4 (ID), VR403.1; also elsewhere on the board
/Connectors/USBVCC: C402.1, C403.1, F401.2, R403.1; also elsewhere on the board
/Connectors/XUSB: C401.2, F401.1, P401.1 (VCC); also elsewhere on the board
AD0: SHIELD401.AD0; also elsewhere on the board
AD1: SHIELD401.AD1; also elsewhere on the board
AD2: SHIELD401.AD2; also elsewhere on the board
AD3: SHIELD401.AD3; also elsewhere on the board
AD4: SHIELD401.AD4; also elsewhere on the board
AD5: SHIELD401.AD5; also elsewhere on the board
AD6: SHIELD401.AD6; also elsewhere on the board
AD7: SHIELD401.AD7; also elsewhere on the board
AD8: SHIELD401.AD8; also elsewhere on the board
AD9: SHIELD401.AD9; also elsewhere on the board
AD10: SHIELD401.AD10; also elsewhere on the board
AD11/TXD3: SHIELD401.AD11; also elsewhere on the board
AD14/RXD3: SHIELD401.52 (PB1); also elsewhere on the board
AREF: SHIELD401.AREF; also elsewhere on the board
CANRX0: SHIELD401.C_RX (CANRX); also elsewhere on the board
CANTX0: SHIELD401.C_TX (CANTX); also elsewhere on the board
CANTX1/IO: SHIELD401.53 (PB0); also elsewhere on the board
DAC0/CANRX1: SHIELD401.DAC0; also elsewhere on the board
DAC1: SHIELD401.DAC1; also elsewhere on the board
JTAG_RESET: JP401.10, R401.7, SJ401.1
JTAG_TCK: C405.2, DEBUG401.2, JP401.4, R401.3 (7); also elsewhere on the board
JTAG_TDI: C406.2, JP401.8, R401.5 (7); also elsewhere on the board
JTAG_TDO: C407.2, JP401.6; also elsewhere on the board
JTAG_TMS: C404.2, DEBUG401.3, JP401.2, R401.1 (7); also elsewhere on the board
MISO: SHIELD401.SP1 (MISO); also elsewhere on the board
MOSI: SHIELD401.SP4 (MOSI); also elsewhere on the board
PIN22: SHIELD401.22 (PA0); also elsewhere on the board
PIN23: SHIELD401.23 (PA1); also elsewhere on the board
PIN24: SHIELD401.24 (PA2); also elsewhere on the board
PIN25: SHIELD401.25 (PA3); also elsewhere on the board
PIN26: SHIELD401.26 (PA4); also elsewhere on the board
PIN27: SHIELD401.27 (PA5); also elsewhere on the board
PIN28: SHIELD401.28 (PA6); also elsewhere on the board
PIN29: SHIELD401.29 (PA7); also elsewhere on the board
PIN30: SHIELD401.30 (PC7); also elsewhere on the board
PIN31: SHIELD401.31 (PC6); also elsewhere on the board
PIN32: SHIELD401.32 (PC5); also elsewhere on the board
PIN33: SHIELD401.33 (PC4); also elsewhere on the board
PIN34: SHIELD401.34 (PC3); also elsewhere on the board
PIN35: SHIELD401.35 (PC2); also elsewhere on the board
PIN36: SHIELD401.36 (PC1); also elsewhere on the board
PIN37: SHIELD401.37 (PC0); also elsewhere on the board
PIN38: SHIELD401.38 (PD7); also elsewhere on the board
PIN39: SHIELD401.39 (PG2); also elsewhere on the board
PIN40: SHIELD401.40 (PG1); also elsewhere on the board
PIN41: SHIELD401.41 (PG0); also elsewhere on the board
PIN42: SHIELD401.42 (PL7); also elsewhere on the board
PIN43: SHIELD401.43 (PL6); also elsewhere on the board
PIN44: SHIELD401.44 (PL5); also elsewhere on the board
PIN45: SHIELD401.45 (PL4); also elsewhere on the board
PIN46: SHIELD401.46 (PL3); also elsewhere on the board
PIN47: SHIELD401.47 (PL2); also elsewhere on the board
PIN48: SHIELD401.48 (PL1); also elsewhere on the board
PIN49: SHIELD401.49 (PL0); also elsewhere on the board
PIN50: SHIELD401.50 (PB3); also elsewhere on the board
PIN51: SHIELD401.51 (PB2); also elsewhere on the board
PWM2: SHIELD401.2; also elsewhere on the board
PWM3: SHIELD401.3; also elsewhere on the board
PWM5: SHIELD401.5; also elsewhere on the board
PWM6: SHIELD401.6; also elsewhere on the board
PWM7: SHIELD401.7; also elsewhere on the board
PWM8: SHIELD401.8; also elsewhere on the board
PWM9: SHIELD401.9; also elsewhere on the board
PWM11: SHIELD401.11; also elsewhere on the board
PWM12: SHIELD401.12; also elsewhere on the board
PWM13: SHIELD401.13; also elsewhere on the board
RXD0: SHIELD401.15 (RX3); also elsewhere on the board
RXD1: SHIELD401.17 (RX2); also elsewhere on the board
RXD2: SHIELD401.19 (RX1); also elsewhere on the board
SCK: SHIELD401.SP3 (SCK); also elsewhere on the board
SCL0-3: SHIELD401.21 (SCL); also elsewhere on the board
SCL1: SHIELD401.SCL1; also elsewhere on the board
SDA0-3: SHIELD401.20 (SDA); also elsewhere on the board
SDA1: SHIELD401.SDA1; also elsewhere on the board
SS0/PWM10: SHIELD401.10; also elsewhere on the board
SS1/PWM4: SHIELD401.4; also elsewhere on the board
TXD0: SHIELD401.14 (TX3); also elsewhere on the board
TXD1: SHIELD401.16 (TX2); also elsewhere on the board
TXD2: SHIELD401.18 (TX1); also elsewhere on the board
VIN: SHIELD401.V_IN; also elsewhere on the board

Notes on the sheet:
Debug Port (SWD)
Native USB AB
JTAG
Arduino Headers

Notices in the files:
EtherDue.kicad_pcb:
Under Creative Commons Attribution ShareAlike License
Licensed by Freetronics Pty Ltd
analog-io.sch:
Derived from EtherDue - (C) 2014 Freetronics Pty Ltd
Licensed under Creative Commons Share-Alike
