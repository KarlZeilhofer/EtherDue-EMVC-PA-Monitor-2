# Repository KarlZeilhofer/EtherDue-EMVC-PA-Monitor-2 (continued)

## KiCad design EtherDue.kicad_pcb (continued)

Parts:
C601, C602: 22pF; SM0402
C603, C605, C607, C609, C610, C611: 100nF; SM0402
C604, C606, C608: 10uF 6.3V A TANT; SMD-1206_Pol
D601, D605, D606: YELLOW; LED-0603
D602, D603: GREEN; LED-0603
D604: RED; LED-0603
IC601: W5100; SQFP80
JP601: M04; FT-POE-MODULE-NOOUTLINE
L601, L602: 1uH 250mA; 0805
Q601: 2N7002; SOT23
R601, R604: 1K; RES_CAY16
R602: 1M; SM0402_r
R603: 12K3 1%; SM0402_r
R605: 49R9 1%; RES_CAY16
R606, R607: 1K; SM0402_r
SJ601: OPEN; SJ_OPEN
U602: HY931147C
U603: APX811-31UG-7; SOT143-R
X601: TXC 7A 25MHz 18pF; TXC_7A

Connections:
+3.3V: C603.1, D601.A, D602.A, D603.A, D604.A, D605.A, D606.A, IC601.12 (VCC3V3D), IC601.18 (VCC3V3D), IC601.44 (VCC3V3D), L602.1, R601.2 (8), R601.4 (8), U602.11 (Y+), U602.13 (G+), U603.4 (VCC); also elsewhere on the board
/Connectors//MASTER-RESET: U603.3 (/MR); also elsewhere on the board
/Ethernet/1V8A: C606.1, IC601.7 (VCC1V8A), IC601.74 (VCC1V8A), L601.2
/Ethernet/1V8D: C604.1, C605.1, C607.1, IC601.11 (1V8_OUT), IC601.15 (VCC1V8D), IC601.16 (VCC1V8D), IC601.33 (VCC1V8D), IC601.69 (VCC1V8D), L601.1
/Ethernet/3V3A: C608.1, C611.1, IC601.2 (VCC3V3A), L602.2, U602.3 (RXCT), U602.4 (TXCT)
/Ethernet/COLLED: IC601.71 (COLLED), R604.5 (7)
/Ethernet/FDXLED: IC601.70 (FDXLED), R604.7, R607.1
/Ethernet/LINKLED: IC601.66 (LINKLED), R601.7, R606.1
/Ethernet/POE_V+: JP601.3, U602.9 (V+)
/Ethernet/POE_V-: JP601.2, U602.10 (V-)
/Ethernet/RXLED: IC601.72 (RXLED), R604.3 (7)
/Ethernet/SPDLED: IC601.67 (SPDLED), R601.5 (7)
/Ethernet/TXLED: IC601.73 (TXLED), R604.1 (7)
/Ethernet/WIZRST: IC601.59 (/RESET), U603.2 (/RESET)
MISO: IC601.27 (MISO); also elsewhere on the board
MOSI: IC601.28 (MOSI); also elsewhere on the board
unnamed: C601.1, IC601.75 (XTLN), R602.2, X601.1
unnamed: C602.1, IC601.76 (XTLP), R602.1, X601.2
unnamed: C609.1, R605.1, R605.3 (P2)
unnamed: C610.1, R605.5 (P3), R605.7 (P4)
unnamed: D601.K, R601.8
unnamed: D602.K, R601.6 (8)
unnamed: D603.K, R604.8
unnamed: D604.K, R604.6 (8)
unnamed: D605.K, R604.4 (8)
unnamed: D606.K, R604.2 (8)
unnamed: IC601.1 (RSET_BG), R603.1
unnamed: IC601.5 (RXIP), R605.8 (R4), U602.1 (RX+)
unnamed: IC601.6 (RXIN), R605.6 (R3), U602.2 (RX-)
unnamed: IC601.8 (TXOP), R605.2 (R1), U602.5 (TX+)
unnamed: IC601.9 (TXON), R605.4 (R1), U602.6 (TX-)
unnamed: IC601.31 (SEN), Q601.3 (D), R601.1 (7)
unnamed: IC601.55 (/CS), IC601.57 (/WR), IC601.58 (/RD), R601.3 (7)
unnamed: IC601.56 (/INT), SJ601.2
unnamed: R606.2, U602.12 (Y-)
unnamed: R607.2, U602.14 (G-)
PWM2: SJ601.1; also elsewhere on the board
SCK: IC601.30 (SCLK); also elsewhere on the board
SS0/PWM10: IC601.29 (/SCS), Q601.1 (G); also elsewhere on the board
VIN: JP601.4; also elsewhere on the board

Notes on the sheet:
W5100 Reset on Poweron
Analog Power Decoupling
For DC PoE with low voltage, jumper 3(PoE_V+) to 4(VIN) & 2(PoE_V-) to 1(GND)
Direct feed to Arduino VIN
PoE Module Header
1.8v decoupling: 1 near pins 15/16, 1 near pin 33
/SCS & SS0 Behaviour: MISO pin tri-state by SS & /SCS SS0 low simultaneously drives SEN high -> SPI enabled & chip selected
Reset IC - 140ms min, 280ms max < 3.08 Vrst, push-pull output

Parts:
C701: 100nF; SM0402
SJ701, SJ702: SJ; SJ_SHORTED
U701: MICROSD; MICRO-SD-SOCKET-PP
U702: 24AA025E48; SOT23-6

Connections:
+3.3V: C701.1, U701.4 (VCC); also elsewhere on the board
+5V: U702.6 (Vcc); also elsewhere on the board
MISO: U701.7 (DO); also elsewhere on the board
MOSI: U701.3 (DI); also elsewhere on the board
unnamed: SJ701.2, U702.1 (SCL)
unnamed: SJ702.2, U702.3 (SDA)
SCK: U701.5 (SCK); also elsewhere on the board
SCL0-3: SJ701.1; also elsewhere on the board
SDA0-3: SJ702.1; also elsewhere on the board
SS1/PWM4: U701.2 (CS#); also elsewhere on the board

Notes on the sheet:
24AA02E48 EEPROM w/ MAC
i2c address 0x50, Cut jumpers if unwanted
MicroSD Card Slot
NB: This device could be run on 3.3V but it happens to be located in a section of the board above a 5V power plane, and it will happily run on 5V.

Parts:
C501: 47uF 25V; c_elec_5x5.3
C502: 10uF 25V; SM1206
C503, C504, C509, C511, C512, C513, C514, C515, C516, C520, C521, C522, C523, C524, C526, C527: 100nF; SM0402
C505: 10nF; SM0402
C506, C507, C517, C518, C519, C528: 10uF; SM0603_Capa
C510: 100uF 16V; c_elec_5x5.3
C702: 2n2/50V/COG; C_0603
D501: 1N4004; SMB-DIODE
D502: CD1206-S01575; 1206_DIODE
D503: STPS2L60A; SMA-DIODE
L501, L503, L504, L505: MH2029-300Y; MH2029
L502: 10uH SRR0604-100ML; SRR0604
Q501: BC847BSMD; SOT23_TRANSISTOR
R501: 1K; SM0402_r
R502: 100K; RES_CAY16
R503, R505: 10K; SM0402_r
R504: 52K3; SM0402_r
U203: LMV358IPWR; TSSOP8
U501: POWERJACK; POWER_JACK_PTH
U502: LM2734Y; SOT23-6
U503, U504: FDN340P; SOT23_MOSFET
U505: NCP1117ST33T3G; SOT223

Connections:
+3.3V: C506.1, C515.1, C520.1, C522.1, C524.1, C526.1, C527.1, C528.1, L503.1, L504.1, U203.6 (-), U505.2 (VO); also elsewhere on the board
+5V: C504.1, C510.1, D502.A, L502.2, R504.1, U203.8 (V+), U503.S, U504.S, U505.3 (VI); also elsewhere on the board
/Connectors/USBVCC: U503.D; also elsewhere on the board
/MCU/UOTGVBOF: R501.1; also elsewhere on the board
/MCU/VDDANA: C512.1, C517.1, L503.2; also elsewhere on the board
/MCU/VDDOUT: C507.1, C509.1, C511.1, C516.1, C521.1, C523.1, L505.1; also elsewhere on the board
/MCU/VDDOUTMI: C513.1, C518.1, L504.2; also elsewhere on the board
/MCU/VDDPLL: C514.1, C519.1, L505.2; also elsewhere on the board
/Mega16U2/USBVCCU2: U504.D; also elsewhere on the board
/Power/BUCK_FB: R504.2, R505.1, U502.3 (FB)
/Power/BUCK_OUT: C505.1, D502.K, U502.1 (BOOST)
/Power/BUCK_SW: C505.2, D503.K, L502.1, U502.6 (SW)
/Power/CMP: C503.1, Q501.C, R502.5 (7), R502.8, U203.5 (+)
/Power/GATE_CMD: U203.7, U503.G
unnamed: Q501.B, R501.2, R502.4 (8)
unnamed: R503.2, U502.4 (EN)
VIN: C501.1, C502.1, C702.1, L501.2, R502.6 (8), R503.1, U502.5 (VIN); also elsewhere on the board
VIN_JACK: D501.K, L501.1, U501.2 (PWR); also elsewhere on the board

Notes on the sheet:
4xVDDCORE 100nF decoupling caps + 1x bulk cap
Place near MCU
6x 100nF decoupling, 1ea for MCU pins: VDDIN, VDDBU, 4xVDDIO
MCU Power Decoupling
VBUSPO: VBus Polarity Off 0: The UOTGVBOF output signal is in its default mode (active high) 1: The UOTGVBOF output signal is inverted (active low)
Forces off the power supply to USB port when the USB port is in HOST mode (and the board is powered from an external supply via VIN)
USB Power
3.3V Regulator
5V Regulator
Vin
7-12V Recommended, 6-20V Possible.

Parts:
C801, C805, C806, C807, C813, C815, C816, C817: 10u/25V/X7R; C_1206
C802: 2n2/50V/COG; C_0603
C803, C804: 100n/X7R; C_0603
C808: 1u/25V/X7R; C_0805
C809, C810, C811, C812, C814, C818, C819, C820: 10n/X7R; C_0603
D801: ZENER2; Diode-SMB_Standard
F801: SMD100F; SMD050F
JP801: JUMPER3; Pin_Header_Straight_1x03
L801: WE-TI-744732331; WE-TI_8075_SHRINKTUBE
L802, L803, L804, L805: WE-CBF-742792093; R_0805
P801: MSTBV2
R801, R802: 18k; R_0603
R803, R804, R806: 22k; R_0603
R805, R807: 2k2; R_0603
R808: 3k9; R_0603
R809, R810, R811: 0R; R_0603
U801, U802, U803: TPS7A4501DCQT; DCQ(R-PDSO-G6)
U804: REG101NA-5; DBV(R-PDSO-G5)

Connections:
+3.3V: L803.1; also elsewhere on the board
+5V: L802.1; also elsewhere on the board
/Analog I/O/+3V3: C804.1, L805.2; also elsewhere on the board
/Analog I/O/+5VA: C813.1, C814.1, U804.5 (OUT); also elsewhere on the board
/Analog I/O/+12V: R810.2; also elsewhere on the board
/CAN-Bus/+5V: C803.1, L804.2; also elsewhere on the board
/PA-Monitor Power Supply/+8V: C808.1, R811.2, U804.1 (IN), U804.3 (EN); also elsewhere on the board
/PA-Monitor Power Supply/VIN: C801.1, C802.1, C805.1, C806.1, C807.1, JP801.1, L801.2, U801.1 (SHDN\), U801.2 (IN), U802.2 (IN), U803.1 (SHDN\), U803.2 (IN)
unnamed: C809.1, U804.4 (NR)
unnamed: C810.1, C815.1, C818.1, R801.1, R809.1, U801.4 (OUT)
unnamed: C810.2, R801.2, R804.2, R805.2, U801.5 (ADJ)
unnamed: C811.1, C816.1, C819.1, R802.1, R810.1, U802.4 (OUT)
unnamed: C811.2, R802.2, R806.2, R807.2, U802.5 (ADJ)
unnamed: C812.1, C817.1, C820.1, R803.1, R811.1, U803.4 (OUT)
unnamed: C812.2, R803.2, R808.2, U803.5 (ADJ)
unnamed: D801.K, F801.2, L801.1
unnamed: JP801.2, U802.1 (SHDN\)
unnamed: L802.2, L804.1
unnamed: L803.2, L805.1
PIN24: JP801.3; also elsewhere on the board
VIN_JACK: F801.1, P801.1; also elsewhere on the board

Notes on the sheet:
Versorgung 13...15V
1.21V
power down on alert
permanent active
poly fuse

Schematic: can-bus.sch, High Frequency Power Amplifier Monitor on EtherDue

Parts:
C901, C902: 100n/X7R; C_0603
L901: WE-SL1-744212510; WE-SL1
P901, P902: 677006144621; Firewire-Female-WE677006144621
R901: 1k8; R_0603
R902: 1k; R_0603
R903: 47k; R_0603
R904, R905: 60R; R_1206
R906, R907: 1k3; R_0603
SJ901, SJ902: Solder-Jumper; SJ_2W
U901: TJA1040T; SOIC-8_3.9x4.9mm_Pitch1.27mm

Connections:
/CAN-Bus/+5V: C901.1, U901.3 (VCC); also elsewhere on the board
CANRX0: R901.1, R902.2; also elsewhere on the board
CANTX0: U901.1 (TXD); also elsewhere on the board
unnamed: C902.1, SJ901.C, SJ902.C, U901.5 (SPLIT)
unnamed: L901.1 (AA), R904.2, R906.2, U901.7 (CANH)
unnamed: L901.3 (SA), R905.2, R907.2, U901.6 (CANL)
unnamed: L901.4 (SB), P901.3, P902.3
unnamed: L901.5 (AB), P901.4, P902.4
unnamed: R902.1, U901.4 (RXD)
unnamed: R903.1, U901.8 (STB)
unnamed: R904.1, SJ901.1
unnamed: R905.1, SJ901.2
unnamed: R906.1, SJ902.1
unnamed: R907.1, SJ902.2

Notes on the sheet:
Firewire Connectors are used for CAN
Level shift 5V to 3.3V

Schematic: analog-io.sch, High Frequency Power Amplifier Monitor on EtherDue

Parts:
C1001, C1002, C1005, C1006, C1007, C1008, C1011, C1012, C1014, C1015, C1016, C1019, C1020, C1021, C1024, C1025, C1027, C1028, C1029, C1030, C1031, C1032: 100n/X7R; C_0603
C1003, C1004, C1009, C1010, C1017, C1018, C1022, C1023, C1034, C1035, C1036, C1037: 1n/X7R; C_0603
C1013, C1026, C1033: 10u/25V/X7R; C_1206
D1001, D1002, D1003, D1004: BAT54S; sot23
JP1001, JP1002, JP1003, JP1004: JUMPER3; Pin_Header_Straight_1x03
LED1001: RED; LED-0805
Q1001: BSS308; sot23-gsd
R1001, R1002, R1003, R1004, R1005, R1006, R1007, R1008, R1014, R1015: 100R; R_0603
R1009, R1010, R1011, R1012: 5k6; R_0603
R1013, R1016, R1017: 4k7; R_0603
U1001: AD7294BSUZ; QFP40P900X900X120-64N
VR1001, VR1002, VR1003, VR1004: 10k; Potentiometer_Bourns_3296W_3-8Zoll_Inline_ScrewUp
X1001, X1002, X1003, X1004, X1005, X1006, X1007, X1008, X1009, X1010, X1011, X1012: SMB; SMB-RS#420-5401_wirepad

Connections:
/Analog I/O/+3V3: C1032.1, Q1001.S, R1013.2, R1016.2, R1017.2, U1001.42 (VDRIVE); also elsewhere on the board
/Analog I/O/+5VA: C1003.1, C1009.1, C1013.1, C1016.1, C1017.1, C1019.1, C1021.1, C1022.1, C1025.1, C1027.1, C1029.1, D1001.3 (cathode), D1002.3 (cathode), D1003.3 (cathode), D1004.3 (cathode), U1001.5 (AVDD1), U1001.8 (AVDD2), U1001.14 (AVDD3), U1001.25 (AVDD4), U1001.56 (AVDD5), U1001.57 (AVDD6), U1001.62 (VPP1), U1001.63 (VPP2); also elsewhere on the board
/Analog I/O/+12V: C1020.1, C1024.1, C1031.1, R1009.2, R1010.2, R1011.2, R1012.2, U1001.21 (DAC_OUTV+_AB), U1001.28 (DAC_OUTV+_CD); also elsewhere on the board
/Analog I/O/VIN1: C1009.2, C1010.1, D1002.2 (AK), U1001.51 (VIN1); also elsewhere on the board
/Analog I/O/VIN3: C1022.2, C1023.1, D1004.2 (AK), U1001.49 (VIN3); also elsewhere on the board
/Analog Level Adoption/I_Fuse1_Out: C1003.2, C1004.1, D1001.2 (AK), U1001.52 (VIN0); also elsewhere on the board
/Analog Level Adoption/I_Fuse2_Out: C1017.2, C1018.1, D1003.2 (AK), U1001.50 (VIN2); also elsewhere on the board
/CAN-Bus/+5V: C1028.1, U1001.44 (DVDD); also elsewhere on the board
unnamed: C1001.1, C1005.1, R1001.2, U1001.12 (D1-)
unnamed: C1001.2, C1007.1, R1002.2, U1001.11 (D1+)
unnamed: C1002.1, C1014.1, R1003.2, U1001.10 (D2+)
unnamed: C1002.2, C1011.1, R1004.2, U1001.9 (D2-)
unnamed: C1006.1, JP1001.2, R1005.2, U1001.18 (OFFSET_IN_A)
unnamed: C1008.1, JP1002.2, R1006.2, U1001.23 (OFFSET_IN_B)
unnamed: C1012.1, JP1003.2, R1007.2, U1001.26 (OFFSET_IN_C)
unnamed: C1015.1, JP1004.2, R1008.2, U1001.31 (OFFSET_IN_D)
unnamed: C1026.1, U1001.53 (REF_ADC)
unnamed: C1030.1, U1001.54 (DCAP)
unnamed: C1033.1, U1001.15 (REF_DAC)
unnamed: C1034.1, U1001.19 (VOUT_A), X1009.2 (center)
unnamed: C1035.1, U1001.22 (VOUT_B), X1010.2 (center)
unnamed: C1036.1, U1001.27 (VOUT_C), X1011.2 (center)
unnamed: C1037.1, U1001.30 (VOUT_D), X1012.2 (center)
unnamed: JP1001.3, R1009.1, VR1001.2, VR1001.3
unnamed: JP1002.3, R1010.1, VR1002.2, VR1002.3
unnamed: JP1003.3, R1011.1, VR1003.2, VR1003.3
unnamed: JP1004.3, R1012.1, VR1004.2, VR1004.3
unnamed: LED1001.A, R1015.1
unnamed: Q1001.D, R1015.2
unnamed: Q1001.G, R1014.2
unnamed: R1001.1, X1001.2 (center)
unnamed: R1002.1, X1002.2 (center)
unnamed: R1003.1, X1003.2 (center)
unnamed: R1004.1, X1004.2 (center)
unnamed: R1005.1, X1005.2 (center)
unnamed: R1006.1, X1006.2 (center)
unnamed: R1007.1, X1007.2 (center)
unnamed: R1008.1, X1008.2 (center)
PIN24: R1013.1, R1014.1, U1001.35 (ALERT\); also elsewhere on the board
SCL0-3: R1017.1, U1001.40 (SCL); also elsewhere on the board
SDA0-3: R1016.1, U1001.39 (SDA); also elsewhere on the board

Notes on the sheet:
Shielded Inputs Temperature Sensors
Shielded Inputs for Offset
Shielded Outputs for Gate-Biasing
I2C Address: 0x61
unused highside current amp
TODO: R berechnen
10-turn potentiometers

Schematic: power-meter.sch, High Frequency Power Amplifier Monitor on EtherDue

Parts:
C1101, C1102, C1113, C1114: 100n/X7R; C_0603
C1103, C1104: 100p/X7R; C_0603
C1105, C1107: 47n/C0G; C_0603
C1106, C1109: 10n/X7R; C_0603
C1108, C1112: 10u/25V/X7R; C_1206
C1110: 47p/C0G; C_0603
C1111: 100n/X7R; C_0805
L1101: WE-CBF-742792093; R_0805
P1101, P1102: CONN_01X02; Pin_Header_Straight_1x02
R1101: 56R/1%; R_0603
R1102: 820R/1%; R_0603
R1103, R1106: 0R; R_0603
R1104: 12k; R_0805
R1105: 2k2; R_0805
U1101: ADL5513; LFCSP16
U1102: REG101NA-5; DBV(R-PDSO-G5)
X1101: SMA; SMA-RS#616-3422
X1102, X1103: SMB; SMB-RS#420-5401_wirepad

Connections:
/PA-Monitor Power Supply/+8V: C1112.1, P1101.2, P1102.2, U1102.1 (IN), U1102.3 (EN); also elsewhere on the board
/Power-Meter Forward 1/+5V_PM: C1106.1, C1108.1, L1101.1, R1104.2, U1102.5 (OUT)
AD0: C1114.1, R1106.2; also elsewhere on the board
unnamed: C1101.1, C1102.1, C1103.1, C1104.1, L1101.2, U1101.1 (VPOS1), U1101.4 (VPOS2)
unnamed: C1105.1, U1101.2 (IN_HI)
unnamed: C1105.2, R1101.2, R1102.2, X1101.2 (center)
unnamed: C1107.1, U1101.3 (IN_LO)
unnamed: C1109.1, U1102.4 (NR)
unnamed: C1110.2, U1101.14 (CLPF)
unnamed: C1111.1, R1104.1, R1105.2, U1101.9 (TADJ)
unnamed: C1113.1, R1103.2, R1106.1, U1101.12 (VOUT), X1102.2 (center), X1103.2 (center)
unnamed: R1103.1, U1101.11 (VSET)

Parts of its further copies:
C1201, C1202, C1213, C1214, C1302, C1313, C1314, C1401, C1402, C1413, C1414, C1603, C1613, C1614, C1713, C1714, C1802, C1803, C1813, C1814: 100n/X7R; C_0603
C1203, C1204, C1303, C1304, C1403, C1404, C1605: 100p/X7R; C_0603
C1205, C1207, C1305, C1307, C1405, C1407, C1606: 47n/C0G; C_0603
C1206, C1209, C1306, C1309, C1406, C1409, C1607, C1609: 10n/X7R; C_0603
C1208, C1212, C1308, C1312, C1408, C1412, C1608: 10u/25V/X7R; C_1206
C1210, C1310, C1410, C1610: 47p/C0G; C_0603
C1211, C1311, C1411, C1611, C1711, C1811: 100n/X7R; C_0805
L1201, L1301, L1401, L1601, L1801: WE-CBF-742792093; R_0805
P1201, P1202, P1301, P1302, P1401, P1402, P1601, P1602, P1701, P1702, P1801, P1802: CONN_01X02; Pin_Header_Straight_1x02
R1201, R1401: 56R/1%; R_0603
R1202, R1402: 820R/1%; R_0603
R1203, R1206, R1303, R1306, R1403, R1406: 0R; R_0603
R1204, R1304, R1404: 12k; R_0805
R1205, R1305, R1405: 2k2; R_0805
U1201, U1301, U1401, U1601: ADL5513; LFCSP16
U1202, U1302, U1402, U1602: REG101NA-5; DBV(R-PDSO-G5)
X1201, X1301, X1401, X1601, X1701, X1801: SMA; SMA-RS#616-3422
X1202, X1203, X1302, X1303, X1402, X1403, X1602, X1603, X1702, X1703, X1802, X1803: SMB; SMB-RS#420-5401_wirepad

Connections of its further copies:
/Analog I/O/VIN1: C1314.1, R1306.2; also elsewhere on the board
/Analog I/O/VIN3: C1414.1, R1406.2; also elsewhere on the board
/PA-Monitor Power Supply/+8V: C1212.1, C1312.1, C1412.1, P1201.2, P1202.2, P1301.2, P1302.2, P1401.2, P1402.2, U1202.1 (IN), U1202.3 (EN), U1302.1 (IN), U1302.3 (EN), U1402.1 (IN), U1402.3 (EN); also elsewhere on the board
/Power-Meter Forward 2/+5V_PM: C1206.1, C1208.1, L1201.1, R1204.2, U1202.5 (OUT)
/Power-Meter Return 1/+5V_PM: C1306.1, C1308.1, L1301.1, R1304.2, U1302.5 (OUT)
/Power-Meter Return 2/+5V_PM: C1406.1, C1408.1, L1401.1, R1404.2, U1402.5 (OUT)
AD1: C1214.1, R1206.2; also elsewhere on the board
unnamed: C1201.1, C1202.1, C1203.1, C1204.1, L1201.2, U1201.1 (VPOS1), U1201.4 (VPOS2)
unnamed: C1205.1, U1201.2 (IN_HI)
unnamed: C1205.2, R1201.2, R1202.2, X1201.2 (center)
unnamed: C1207.1, U1201.3 (IN_LO)
unnamed: C1209.1, U1202.4 (NR)
unnamed: C1210.2, U1201.14 (CLPF)
unnamed: C1211.1, R1204.1, R1205.2, U1201.9 (TADJ)
unnamed: C1213.1, R1203.2, R1206.1, U1201.12 (VOUT), X1202.2 (center), X1203.2 (center)
unnamed: C1305.1, U1301.2 (IN_HI)
unnamed: C1307.1, U1301.3 (IN_LO)
unnamed: C1309.1, U1302.4 (NR)
unnamed: C1310.2, U1301.14 (CLPF)
unnamed: C1311.1, R1304.1, R1305.2, U1301.9 (TADJ)
unnamed: C1313.1, R1303.2, R1306.1, U1301.12 (VOUT), X1302.2 (center), X1303.2 (center)
unnamed: C1401.1, C1402.1, C1403.1, C1404.1, L1401.2, U1401.1 (VPOS1), U1401.4 (VPOS2)
unnamed: C1405.1, U1401.2 (IN_HI)
unnamed: C1405.2, R1401.2, R1402.2, X1401.2 (center)
unnamed: C1407.1, U1401.3 (IN_LO)
unnamed: C1409.1, U1402.4 (NR)
unnamed: C1410.2, U1401.14 (CLPF)
unnamed: C1411.1, R1404.1, R1405.2, U1401.9 (TADJ)
unnamed: C1413.1, R1403.2, R1406.1, U1401.12 (VOUT), X1402.2 (center), X1403.2 (center)
unnamed 203: L1801.1; also elsewhere on the board
unnamed 274: L1801.2; also elsewhere on the board
unnamed: R1203.1, U1201.11 (VSET)
unnamed: R1303.1, U1301.11 (VSET)
unnamed: R1403.1, U1401.11 (VSET)

Notes on the sheet:
perforated break away
Power supply
measured power
0.4..2.2V
52.42R
+5V

Schematic: fuse-reset.sch, High Frequency Power Amplifier Monitor on EtherDue

Parts:
C1501, C1504: 100n/X7R; C_0603
C1502: 1u/X7R; C_0805
D1501: BAT54S; sot23
Q1501, Q1502: BSS123; sot23-gsd
R1501: 1k; R_0603
R1502: 100k; R_0603
R1503, R1504, R1505: 10k; R_0603
U1501: 4013_with_supply; SOIC-14_3.9x8.7mm_Pitch1.27mm

Connections:
/Analog I/O/+3V3: U1501.14 (VDD); also elsewhere on the board
unnamed: C1501.1, R1501.2
unnamed: C1501.2, D1501.2 (AK)
unnamed: Q1501.G, R1503.2
unnamed: Q1502.G, R1505.1
PIN46: U1501.3 (Cp); also elsewhere on the board
PIN47: U1501.11 (Cp); also elsewhere on the board
PIN48: R1501.1; also elsewhere on the board

Parts of its further copies:
C1601, C1604: 100n/X7R; C_0603
C1602: 1u/X7R; C_0805
D1601: BAT54S; sot23
Q1601, Q1602: BSS123; sot23-gsd
R1601: 1k; R_0603
R1602: 100k; R_0603
R1603, R1604, R1605: 10k; R_0603

Connections of its further copies:
/Fuse-Reset B/Reset\: Q1602.D; also elsewhere on the board
unnamed: C1601.1, R1601.2
unnamed: C1601.2, D1601.2 (AK)
unnamed: Q1601.G, R1603.2
unnamed: Q1602.G, R1605.1
PIN49: R1601.1; also elsewhere on the board

Notes on the sheet:
open drain output
asynchronous reset -> monoflop
1kHz
The reset output is pulsed low, when a) a 1kHz (digital, 3.3V) signl is applied to the Enable_AC input and b) a rising edge is applied to Clock input
Decoupling C is on parent sheet
